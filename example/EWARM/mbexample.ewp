# IAR project mbexample.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../User/Inc; ../Drivers/CMSIS/Include; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/LwIP/src/include; ../Middlewares/LwIP/system; ../Middlewares/LwIP/src/include/netif/ppp; ../Middlewares/LwIP/src/include/lwip; ../Middlewares/LwIP/src/include/lwip/apps; ../Middlewares/LwIP/src/include/lwip/priv; ../Middlewares/LwIP/src/include/lwip/prot; ../Middlewares/LwIP/src/include/netif; ../Middlewares/LwIP/src/include/posix; ../Middlewares/LwIP/src/include/posix/sys; ../Middlewares/LwIP/system/arch; ..\Middlewares\Modbus; ..\Middlewares\Modbus\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mbexample.srec
  ILINK.IlinkOutputFile: mbexample.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../User/Src/: canprocess.c ethernetif.c httpprocess.c lwipprocess.c main.c mblocalStation.c stm32f4xx_hal_msp.c stm32f4xx_it.c systemprocess.c tcpprocess.c telnetprocess.c tftpfunction.c tftpprocess.c udpprocess.c usart1process.c usart3process.c
    ../User/Inc/: noos_config.h
  group Drivers/CMSIS
    ../User/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/LwIP
    ../Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/Modbus
    ../Middlewares/Modbus/src/: mbascii.c mbasciimaster.c mbasciislave.c mbcommon.c mbpdu.c mbrtu.c mbrtumaster.c mbrtuslave.c mbtcp.c mbtcpclient.c mbtcpserver.c
